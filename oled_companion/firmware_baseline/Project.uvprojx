# Keil uVision project Project.uvprojx, settings and files
target Defuse_Base (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(64000000) ELITTLE
  output: Defuse_Base +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --split_sections
  c include: .\Start;.\Library;.\User;.\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group Hardware
    ./Hardware/: platform.c platform.h check_i2c.c check_i2c.h imu.c imu.h display.c display.h font.h controls.c controls.h zh12.h ui_text.h ui_text_list.h ui_assets.c ui_assets.h ui_pages.c ui_pages.h ui_actions.c ui_actions.h
  group User
    ./User/: main.c config.h stm32f10x_conf.h
