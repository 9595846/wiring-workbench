# Keil uVision project Project.uvprojx, settings and files
target ScannerFixture ()
  device: STM32F103C8
  group Hardware
    Hardware/: display.c
